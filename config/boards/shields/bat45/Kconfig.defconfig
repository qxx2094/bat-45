## config/boards/shields/bat45/Kconfig.defconfig
```kconfig
# SPDX-License-Identifier: MIT

if SHIELD_BAT45

config ZMK_KEYBOARD_NAME
    default "bat45"

endif
```
